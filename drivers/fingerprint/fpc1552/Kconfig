## drivers/fingerprint/fpc1552/Kconfig
```kconfig
config BBK_FPC1552
	tristate "FPC OEM fingerprint FPC1511 support"
	help
	  there is nothing for help!  
```
